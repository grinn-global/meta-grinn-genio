FILESEXTRAPATHS:prepend:grinn-genio-360-360p-sbc := "${THISDIR}/grinn-genio-360-360p-sbc:"
FILESEXTRAPATHS:prepend:grinn-genio-510-sbc := "${THISDIR}/grinn-genio-510-sbc:"
FILESEXTRAPATHS:prepend:grinn-genio-700-sbc := "${THISDIR}/grinn-genio-700-sbc:"
