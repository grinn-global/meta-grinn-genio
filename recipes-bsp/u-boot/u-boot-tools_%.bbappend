inherit python3native
export STAGING_INCDIR="${STAGING_INCDIR_NATIVE}"
