FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-fix-nents-passed-to-dma_unmap_sg.patch;patchdir=.."

