# meta-tensorflow master uses the styhead layout, restore the scarthgap one
S = "${WORKDIR}"
UNPACKDIR = "${WORKDIR}"
