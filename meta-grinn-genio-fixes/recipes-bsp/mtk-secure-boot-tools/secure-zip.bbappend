inherit python3native
DEPENDS:append = " python3-native"
