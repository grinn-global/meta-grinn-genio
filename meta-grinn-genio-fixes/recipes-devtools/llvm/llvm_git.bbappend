FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-CMake-Add-tablegen-job-pool-support.patch"
