# build/tmp/work/grinn_genio_510_sbc-poky-linux/u-boot/git/git/tools/mkeficapsule.c:21:10: fatal error: gnutls/gnutls.h: No such file or directory
#   21 | #include <gnutls/gnutls.h>
#      |          ^~~~~~~~~~~~~~~~~
# compilation terminated.

DEPENDS += "gnutls-native"
