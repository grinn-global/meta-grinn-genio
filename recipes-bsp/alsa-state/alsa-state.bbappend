FILESEXTRAPATHS:prepend:grinn-genio-700-sbc := "${THISDIR}/grinn-genio-700-sbc:"
