CXXFLAGS += "-fPIC"
BUILD_CXXFLAGS += "-fPIC"

require flatbuffers.inc
